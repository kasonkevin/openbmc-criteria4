IMAGE_INSTALL:append = " login-audit host-console-monitor"
