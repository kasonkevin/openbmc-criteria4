EXTRA_OEMESON:append = " -Dredfish-bmc-journal=enabled"
EXTRA_OEMESON:append = " -Dredfish-dbus-log=enabled"
